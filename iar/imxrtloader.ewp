# IAR project imxrtloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\src; ..\cmsis; ..\drivers; ..\drivers\device; ..\framework2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: imxrtloader.srec
  ILINK.IlinkOutputFile: imxrt1052loader.out
  ILINK.IlinkIcfFile: imxrt1052_ram.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration onlytest (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: imxrt1052_flexspi.icf
  group drivers
    ../drivers/: fsl_clock.c fsl_common.c fsl_flexspi.c fsl_gpio.c fsl_lpuart.c
  group framework
    ../framework2/: flash_loader.c flash_loader_asm.s
  group usr
    ../src/: device_config.c flash_loader_ram.c otcal_adesto.c quad_flash.c
    ../drivers/device/: system_MIMXRT1052.c
